# Keil uVision project 0project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 0project +hex
  AfterMake: fromelf.exe --bin obj/0project.axf --output 0project.bin
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\system;..\user;..\hal;..\FWLIB\CMSIS;..\stm_os\include;..\system\fcmd
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../user/: main.c app_task.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c xprintf.c
    ../SYSTEM/fcmd/: cmd_mem.c fcmd.c fcmd_cfg.h
  group FWLIB
    ../FWLIB/: STM32FWLIB_V35.lib
    ../FWLIB/CMSIS/: core_cm3.c system_stm32f10x.c
    ../FWLIB/startup/: startup_stm32f10x_hd.s
  group hal
    ../hal/: hal_driver.c led.c
  group stm_os
    ../stm_os/: event.c mem.c power.c stm.c timer.c cpu.asm
    ../stm_os/include/: event.h event_driven.h mem.h port.h power.h stm.h timer.h type.h
